# KOMPAS-3D part (spoon.m3d)

Model tree:
1. Поверхность без истории:1
2. Придать толщину:1
     Толщина стенки 1 = 1; Толщина стенки 2 = 1
3. Масштабирование:1
     Коэффициент = 0.25
